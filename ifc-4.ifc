Properties of the parts of a building model (IFC4)

# File
Description: Dichtungsset für Universalkapillarthermostate RTKSA-xxx.xxx, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: KA999904, Dichtungsset für Universalkapillarthermostate RTKSA-xxx.xxx
In: Raum
Description: Dichtungsset für Universalkapillarthermostate RTKSA-xxx.xxx. Mit diesem Dichtungsset kann die Schutzart auf IP54 erhöht werden.; Classification: EC001231 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: KA999904; ModelLabel: JZ-33; GlobalTradeItemNumber: 4050528077165; ProductURL: https://alre.de/produkt_KA999904
Pset_Specification - NominalLength: 0.032 m; NominalWidth: 0.0225 m; NominalDepth: 0.0225 m; NetWeight: 0.012
Pset_ALRE_ETIM_Properties - Ausführung: sonstige; Länge: 22.5; ETIM-Klasse: EC001231; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-KA999904.pdf
